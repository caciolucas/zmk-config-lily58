## Kconfig
```kconfig
config ZMK_KEYSTATUS_BLE
    bool "KeyStatus BLE GATT service (layer + BT profile reporting)"
    default n
    depends on BT
```
